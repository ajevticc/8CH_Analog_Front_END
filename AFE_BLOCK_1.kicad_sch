File: AFE_BLOCK_1.kicad_sch (KiCad schematic)
At the start: 2 parts, among them U1201 LPF, U1202 LPF

Commit message: Routing new channels
Parts:
- renumbered U1201 to U2801, U1202 to U2802
